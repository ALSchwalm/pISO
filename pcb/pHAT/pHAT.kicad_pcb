# Repository ALSchwalm/pISO

File README:

Building with docker
--------------------

Just have docker installed and run:

    ./build.sh

Building without docker
-----------------------

Without docker, you will need to first ensure you have all of the appropriate
dependencies installed (see [this list](https://buildroot.org/downloads/manual/manual.html#requirement) ).

    cd buildroot
    cp configs/raspberrypi0_defconfig .config
    make

Either approach should produce a file in `buildroot/output/images/sdcard.img`. This file can
be written directly to an SD card (e.x., with `dd`).

License
-------

The pISO source code and hardware designs are licensed under the terms of the GNU General Public
License 3.0. For additional information see the LICENSE file.

## KiCad design pcb/pHAT/pHAT.kicad_pcb

File pcb/README.txt:

Designed with [KiCad](http://kicad-pcb.org/)

Parts:
A1: VDD5; SLP
B1: VDD5; SLP
C1, C2: 2.2uF; C_0805
DNP1: LOGO
IREF1: 390; R_0805
M1, M2, M3, M4: mount1; mount
NO1: VDD5; SLP
P2: USB_A; usb
P4: CONN_01X30; FPC_30
R1, R2, R3, R5: 10k; R_0805
SW1, SW2, SW3: SW_Push; spst
U1: ATTINY25/45/85; SOIJ-8_5.3x5.3mm_Pitch1.27mm
VBAT1: 2.2uF; C_0805
VCC1: 10uF; C_0805
VCOMH1: 2.2uF; C_0805
VDD1: 2.2uF; C_0805
W1, W2: ExtraPOGO; SLP
W5: POWER; SLP
W7: RST; SLP
W8: CS; SLP
W9: MOSI; SLP
W10: SCLK; SLP
W11: DC; SLP
W12: GND; SLP
W13: 3V3; SLP
W14: D_N; SLP
W15: D_P; SLP

Connections:
+3V3: P4.6, P4.9, R1.1, R2.1, R3.1, R5.1, U1.8 (VCC), VBAT1.2, VDD1.2, W13.1
/CS: P4.13, U1.2 (CS), W8.1
/DC: P4.15, U1.3 (DC), W11.1
/DM1_N: P2.2, W14.1
/DM1_P: P2.3, W15.1
/MOSI: P4.19, U1.5 (MOSI), W9.1
/RST: P4.14, U1.6 (RES/MISO), W7.1
/SCLK: P4.18, U1.7 (SCK), W10.1
GND: IREF1.2, M1.1, M2.1, M3.1, M4.1, P2.4, P2.5, P4.1, P4.8, P4.10, P4.11, P4.12, P4.29, P4.30, SW1.2, SW2.2, SW3.2, U1.4 (GND), VBAT1.1, VCC1.1, VCOMH1.1, VDD1.1, W12.1
unnamed: A1.1, R2.2, SW2.1
unnamed: B1.1, R3.2, SW3.1
unnamed: C1.1, P4.3
unnamed: C1.2, P4.2
unnamed: C2.1, P4.5
unnamed: C2.2, P4.4
unnamed: IREF1.1, P4.26
unnamed: NO1.1, R1.2, SW1.1
unnamed: P2.1, W5.1
unnamed: P4.27, VCOMH1.2
unnamed: P4.28, VCC1.2
unnamed: R5.2, U1.1 (RESET)

Board: 2 copper layers, 65.0 x 30.0 mm, 37 parts (26 on the bottom side), 21 nets.

## Commit log

2017-08-27 Add usb startup script
2017-08-27 Add buildroot configs
2017-10-16 Start adding bitmap and lvm2app
2017-10-16 Include lvm2app
2017-10-20 Added CppGPIO
2017-10-21 Improved vdrive script
2017-10-21 Add gui event handler
2017-10-21 Add virtual drive heading item
2017-10-22 Add buildroot as submodule
2017-10-22 Moved cppgpio submodule
2017-10-24 Move setup in to buildroot overlay
2017-10-25 Get script path from env
2017-10-25 Stip newline from iso name
2017-10-25 Fix bug where base mount path was not string
2017-10-25 More verbose output
2017-10-26 Start switching to using cli over lvm2app
2017-10-27 Move away from lvm2app
2017-11-03 Add config_getenv
2017-11-05 Add display controller
2017-11-05 New buildroot commit
2017-11-07 Small padding to the left in ui
2017-11-08 Rename usb-multitool -> pISO
2017-11-12 Add better rotary encoder
2017-11-15 Add on_focus callback
2017-11-17 Bug fixes for screen/controller
2017-11-17 Add GUIListItem
2017-11-19 Better gui layout
2017-11-20 Implement sidebar for free %
2017-11-20 Use whole number for free %
2017-11-20 Fix flash on lcd during startup
2017-12-03 Fix pins for new board and add mount indicator
2017-12-04 adding current KiCad files, need to update Gerbers
2017-12-04 Start using libusbgx
2017-12-09 PCB layout with buttons
2017-12-09 attiny source code
2017-12-11 Switch back to using sh based setup (seems more reliable)
2017-12-29 Remove rotary encoder
2017-12-30 Allow user to select size of new virtual drive
2017-12-30 Fix 'c' in font
2017-12-30 Use actual size of drive
2017-12-30 Update buildroot
2017-12-31 Add mutex for contoller
2017-12-31 Show GB size during vdrive creation
2017-12-31 Bump version for first pre-release
2018-01-02 Start adding options menu
2018-01-21 Add error display message and create partition table for new drives
2018-01-21 Fix bug where isos with long names could not be mounted
2018-01-22 Fix race condition that could case call to pure virtual function
2018-01-22 Increment version number
2018-01-22 Add logo and splash
2018-01-25 Format new drives by default
2018-01-27 Add option to format drives as they are created
2018-01-28 Long press select to flip screen
2018-02-13 update controller_source, image is negative
2018-03-22 update for USBA board
2018-03-23 usbc
2018-04-06 Add iso menu option
2018-04-06 Continue switch to rust
2018-04-06 Add displaymanager
2018-04-06 Toggle external mount on vdrive click
2018-04-06 Add size selection to rust version
2018-04-06 Added 'up' event handling
2018-04-06 Make the windows for each vdrive the child of the previous one
2018-04-06 Continue adding format menu
2018-04-06 Remove tree concept from display manager
2018-04-06 Add newdrive widget
2018-04-06 Reformat rust and start adding vdrive
2018-04-06 Start adding rust version
2018-04-06 Add event/action handling
2018-04-06 Add configfs configuration
2018-04-06 Fix bug where windows were render in the order they were added rather than the order of .children()
2018-04-06 Start adding drive format screen
2018-04-06 Start adding input logic
2018-04-06 Avoid fake events
2018-04-06 Allow a window to have multiple Normal position children
2018-04-06 Fixup buildroot for rust
2018-04-06 Add status menu on right
2018-04-06 Remove old piso directory
2018-04-07 Fix bug where some lvm reports would not deserialize correctly
2018-04-07 update PCB for 1.2 support
2018-04-15 Add docker/build scripts
2018-04-15 Add license
2018-04-15 update PCB images
2018-04-15 removed notes
2018-04-15 Remove docs folder
2018-04-17 controller souce was not updated in this branch, added binaries so no building is required
2018-04-17 Render readme with markdown
2018-04-18 Start adding wifi menu items
2018-04-22 Add tests for displaymanager
2018-04-22 Continue adding wifi support
2018-04-24 Tests for focus movement
2018-04-24 Add travis config
2018-04-24 Add travis badge
2018-04-25 Add gitlab ci config and makefile
2018-04-25 Cache cargo on gitlab ci
2018-04-25 Fix cargo cache and disable buildroot ccache
2018-04-26 Cache buildroot output in ci
2018-04-26 Make 'should-rebuild' explicitly executable
2018-04-27 Remove broken gitlab-ci link
2018-04-27 Add git dependency for ci builds
2018-04-27 Add gitlab ci badge
2018-04-27 Add note that repo must be cloned recursively
2018-04-27 Do not share ci cache between jobs
2018-04-27 Fix bug where 'should-rebuild' was not executable
2018-04-29 Add generic back button
2018-04-29 Add 'Activate Ap' button and back button for wifi
2018-04-29 Add border to top of newdrive widget
2018-04-29 Activate hostapd when selected
2018-04-30 Use iterator instead of callback for event processing
2018-05-01 Fix compiler warnings
2018-05-04 Render fixed position windows correctly
2018-05-04 Check for cache-version in local builds
2018-05-04 Add working host ap mode
2018-05-04 Fix bug where storage info was not shown in sub menus
2018-05-04 Fix alignment of arrow on newdrive
2018-05-05 Add ability to switch between host and client wifi
2018-05-08 Add usb vendor id/product id
    Allocated from http://http://pid.codes/ see http://pid.codes/1209/0256/
2018-05-09 Create a user from the config for use with wifi
2018-05-11 fixed issue that could cause CS line to short to up button
2018-05-22 Artifact the rootfs file
2018-05-22 Fix bug where vdrive could not be remounted correctly
2018-05-23 Fix bug with bitmaps larger than the display size
2018-05-23 Add menu that shows connected wifi address
2018-05-24 Initial scrolling support
2018-05-26 Label new drives
2018-05-26 Add tag for custom runner to ci
2018-05-26 Make buildroot board scripts executable in ci
2018-05-29 Add state tracking
2018-05-30 Do not read state from disk each event
2018-06-07 Add generic 'drivelist' menu and readonly support
2018-06-11 Add ability to make drives non-removable
2018-06-12 Use constant for ISOS folder name
2018-06-13 Fix bug where child windows were not always focused or positioned correctly
2018-06-14 Add delete drive option
    Note: there is a known bug where you can not delete a drive that you
    created without a powercycle between.
2018-06-15 Add basic snapshot support
    This implements most of #4, but doesn't address the concern about corruption
    there.
2018-06-15 Make size step and default drive size configurable
2018-06-16 Move options under option menu
2018-06-16 Don't show wifi menu for pi's that don't support wifi
2018-06-17 Add debug tar file and message on error
2018-06-19 Move should-rebuild to pISO repo
2018-06-19 Fix 'should-rebuild' for legacy shells
2018-06-26 Add benchmark make target
2018-06-27 Use bindfs to avoid permission problems with user filesystems
2018-06-27 Mount internal into folders with the same names as the vdrives
2018-08-30 Start adding image assets for the wiki
2018-08-31 Add assets for create/delete wiki page
2018-09-01 Add assets for store/mount iso wiki page
2018-09-01 Add assets for readonly/nonremovable wiki page
2018-09-01 Make wifi.client config entries optional
2018-09-02 Use 'zip' instead of 'tar.gz' for sdimage artifact
2018-09-02 Fix bug in buildroot where 'boot' dir was not added
2018-09-02 Update buildroot with dummy file in 'usr-mnt'
2018-09-02 Create /usr-mnt bindfs mountpoint at startup
    Also make bindfs run in multithreaded mode
2018-09-02 Show drive size after name
2018-09-02 Start drive numbering from 1
2018-09-02 Add assets for wifi wiki page
2018-09-02 Add link to 'piso.support' on error screen
2018-09-02 Add another image for the wifi wiki
2018-09-02 Add ip address after connected network name
2018-09-03 Add debounce config option
2018-09-03 Fix bug where text from main menu was visible during drive creation
2018-09-03 Add images for snapshot wiki page
2018-09-03 Update default debounce
2018-09-05 Add images for installation wiki page
2018-09-13 Add user account async
    This is needed because adding entries to the samba db can take a while
    and we don't want to block for several seconds during startup
2018-09-14 Add menus for showing wifi connecting
2018-09-15 Fix race with user creation
    The volume mount point was created async, so automounted volumes could race
2018-09-15 Fixed "Optons" menu typo
2018-09-16 Add option to perform automatic fstrim
2018-09-16 Fix bug where ntfs partition was not mounted internal
2018-09-16 Minor formatting fixes
2018-09-16 Add persistent logging option
2018-09-17 Make 'Universal' drive format FAT32
2018-09-18 Add a way to flip the display
2018-09-21 Add assets for assembly-without-cover section of wiki
2018-09-23 Universal Format (FAT32) needs to be partition type 0x0c to be mountable on MacOS
2018-10-02 Fixed a bug where drive names were calculated badly
    This could result in situations where for example there was a single drive
    named 'Drive2'. The user can then not create any more drives because the
    nexts drive name would be 'Drive2' (because the calculation is just drive
    count + 1). Now we just look for the first available name
2018-10-04 Ignore files in the ISOs folder starting with '.'
2018-10-04 Add support for renaming drives
    This adds a new config option '[[drive]]' that currently has a
    'name' and 'newname' field. If a drive would be created that has
    the name 'name' (e.g., Drive1), then it will be shown with the
    new name instead. This will also change the names given to the
    default partition when creating a new drive. It will not change
    the partition name for an already existing drive (though it will
2018-10-05 Fix bug where internal drive names were visible over wifi
2018-10-07 Update buildroot with new kernel for DVD support
    Previously, exporting an ISO larger than 2GB would silently truncate
    the file. On some systems, the file could still mount but others
    would detect a corrupt filesystem or mount but fail later. Now the
    max ISO size is about 80GB.
2018-10-07 Switch to 'update.zip' for updates
    This avoids some updates only needing an updated rootfs, while
    others require a kernel and initramfs update as well. Now, the
    user just needs to extract this update.zip file to the root of
    their SD card.
2018-10-07 Switch to kernel with capabilities mode page
2018-10-07 Add debug for mode sense
2018-10-08 Update buildroot (and disable cache for this branch)
2018-10-10 Update to kernel with READ TRACK INFO support
2018-10-10 Update buildroot to have 'piso' hostname (fixes #50)
2018-10-10 Fix bug with READ TRACk INFO
2018-10-11 Increase USB MaxPower to 500mA
2018-10-12 Do not show 'plugged in' drives over network (fixes #49)
2018-10-14 Add version menu (fixes #36)
2018-10-14 Use separate smb shares for each partition (fixes #42)
2018-10-18 Update to buildroot with more accurate usb capabilities
2018-10-23 Update buildroot for more accurate cd emulation
2018-10-24 Fix bug where discs would not mount is MacOS (fixes #32)
    This was caused by MacOS issuing a READ DVD STRUCTURE command to determine
    the type of disc being read. When we failed to respond to this, the OS
    starts to attempt to read with CD READ requests instead of standard READ
    requests. We don't support CD READ currently. Now we respond to the first
    request correctly, so MacOS does normal READs and things work correctly.
2018-10-24 Add support for sorting drives by name (fixes #59)
2018-10-24 Allow step_size and default_size to be floats
2018-10-24 Prevent underflow of new drive percent
2018-10-31 Fix bug where non W Raspberry Pi Zeros would hang after driver creation
2018-10-31 Update VERSION file
2018-10-31 Fix bug where usage could be too precise
2018-11-08 Allow step_size and default_size to be floats (fixes #57)
2018-11-08 Prevent underflow of new drive percent (fixes #74)
2018-11-08 Fix bug where non W Raspberry Pi Zeros would hang after driver creation (fixes #66)
2018-11-08 Fix bug where ftp users could write to root
2018-11-13 Add more debug logging
